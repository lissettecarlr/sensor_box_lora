# Keil uVision project project.uvprojx, settings and files
target rt-thread (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32L151CB STMicroelectronics
  pack: Keil.STM32L1xx_DFP.1.2.0
  cpu: IRAM(0x20000000,0x00004000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: rt-thread +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER, STM32L151xB
  c include: .;..\..\..\rt-thread-master\include;applications;.;board;board\CubeMX_Config\Inc;..\libraries\HAL_Drivers;..\libraries\HAL_Drivers\config;..\..\..\rt-thread-master\libcpu\arm\common;..\..\..\rt-thread-master\libcpu\arm\cortex-m3;..\..\..\rt-thread-master\components\drivers\include;..\..\..\rt-thread-master\components\drivers\include;..\..\..\rt-thread-master\components\drivers\spi;..\..\..\rt-thread-master\components\drivers\include;..\..\..\rt-thread-master\components\drivers\include;..\..\..\rt-thread-master\components\finsh;..\libraries\STM32L1xx_HAL\CMSIS\Device\ST\STM32L1xx\Include;..\libraries\STM32L1xx_HAL\STM32L1xx_HAL_Driver\Inc;..\libraries\STM32L1xx_HAL\CMSIS\Include;..\..\..\v6plus\v6plus-package\drivers\sx1276;..\..\..\v6plus\v6plus-package\ulog;..\..\pck\fal\inc;..\..\pck\fal\samples\porting;.\applications;..\..\pck\LowPower;..\..\..\v6plus\v6plus-package\rtc;.\board\CubeMX_Config\Inc;.\applications\htu21d;..\..\..\v6plus\v6plus-package\sensor_ctr;..\..\..\v6plus\v6plus-package\stm32;..\..\..\v6plus\v6plus-package\uart;..\..\..\v6plus\v6plus-package\lorawan
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  scatter file: .\board\linker_scripts\link.sct
  link misc: --keep *.o(.rti_fn.*)   --keep *.o(FSymTab)
  group Kernel
    ../../../rt-thread-master/src/: clock.c components.c cpu.c device.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler.c signal.c thread.c timer.c
  group Applications
    applications/: main.c
    ../../../v6plus/v6plus-package/rtc/: rtc-board.c
    ./applications/: low_power.c
    ../../../v6plus/v6plus-package/sensor_ctr/: sensor_ctr.c sensor_light.c sensor_htu21d.c sensor_power.c
    ../../../v6plus/v6plus-package/stm32/: stm32_HAL_adc.c
    ../../../v6plus/v6plus-package/uart/: sensor_uart_compatible.c sensor_PM2_5.c
  group Drivers
    board/: board.c
    board/CubeMX_Config/Src/: stm32l1xx_hal_msp.c
    ../libraries/STM32L1xx_HAL/CMSIS/Device/ST/STM32L1xx/Source/Templates/arm/: startup_stm32l151xb.s
    ../libraries/HAL_Drivers/: drv_gpio.c drv_usart.c drv_spi.c drv_common.c
  group cpu
    ../../../rt-thread-master/libcpu/arm/common/: backtrace.c div0.c showmem.c
    ../../../rt-thread-master/libcpu/arm/cortex-m3/: cpuport.c context_rvds.S
  group DeviceDrivers
    ../../../rt-thread-master/components/drivers/misc/: pin.c
    ../../../rt-thread-master/components/drivers/serial/: serial.c
    ../../../rt-thread-master/components/drivers/spi/: spi_core.c spi_dev.c
    ../../../rt-thread-master/components/drivers/src/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
  group finsh
    ../../../rt-thread-master/components/finsh/: shell.c symbol.c cmd.c msh.c msh_cmd.c msh_file.c
  group STM32_HAL
    ../libraries/STM32L1xx_HAL/CMSIS/Device/ST/STM32L1xx/Source/Templates/: system_stm32l1xx.c
    ../libraries/STM32L1xx_HAL/STM32L1xx_HAL_Driver/Src/: stm32l1xx_hal_dma.c stm32l1xx_hal_cortex.c stm32l1xx_hal_crc.c stm32l1xx_hal_pwr.c stm32l1xx_hal_rcc.c stm32l1xx_hal_rcc_ex.c stm32l1xx_hal.c stm32l1xx_hal_sram.c stm32l1xx_hal_gpio.c stm32l1xx_hal_uart.c stm32l1xx_hal_usart.c stm32l1xx_hal_spi.c stm32l1xx_hal_spi_ex.c stm32l1xx_ll_spi.c stm32l1xx_hal_pwr_ex.c
    ./board/CubeMX_Config/Drivers/STM32L1xx_HAL_Driver/Src/: stm32l1xx_hal_flash.c stm32l1xx_hal_flash_ex.c stm32l1xx_hal_flash_ramfunc.c stm32l1xx_hal_rtc.c stm32l1xx_hal_rtc_ex.c stm32l1xx_hal_i2c.c stm32l1xx_hal_adc.c stm32l1xx_hal_adc_ex.c
  group sx1276
    ./applications/: sx1276_bsp.c
    ../../../v6plus/v6plus-package/drivers/sx1276/: sx1276.c
  group lorawan
    ./applications/: lorawan_rtt.c node_msg_store.c
    ../../../v6plus/v6plus-package/lorawan/: aes.c cmac.c fifo.c LoRaMacCrypto.c utilities.c lorawan_app.c LoRaMac.c timeServer.c
  group ULOG
    ../../../v6plus/v6plus-package/ulog/: ulog.c
    ../../../v6plus/v6plus-package/ulog/backend/: console_be.c
  group fal
    ../../pck/fal/src/: fal.c fal_flash.c fal_partition.c fal_rtt.c
    ../../pck/fal/samples/porting/: fal_flash_stm32l1_port.c
