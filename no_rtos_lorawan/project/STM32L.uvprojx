# Keil uVision project STM32L.uvprojx, settings and files
target DEBUG (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32L151CB STMicroelectronics
  pack: Keil.STM32L1xx_DFP.1.2.0
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x4000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32L +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_TEST USE_DEBUGGER USE_WIRELESS_CONFIG USE_BAND_470 STM32L1XX_MD USE_STDPERIPH_DRIVER
  c include: ..\apps;..\apps\api;..\apps\privmac;..\boards\stm32\cmsis;..\boards\stm32\common;..\boards\stm32\port;..\boards\stm32\STM32L1xx_StdPeriph_Driver\inc;..\..\..\User\cli;..\mac;..\radio;..\radio\sx1276;..\system;..\system\crypto;..\apps\protocol
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group apps/api
    ../apps/api/: api.c
  group apps/privmac
    ../apps/privmac/: privmac.c
  group boards/cmsis
    ../boards/stm32/cmsis/: stm32l1xx_it.c system_stm32l1xx.c
  group boards/cmsis/startup
    ../boards/stm32/cmsis/startup/: startup_stm32l1xx_md.s
  group boards/common
    ../boards/stm32/common/: eeprom.c gpio.c power.c rtc.c spi.c systick.c uart.c
  group boards/libraries
    ../boards/stm32/STM32L1xx_StdPeriph_Driver/src/: misc.c stm32l1xx_adc.c stm32l1xx_dbgmcu.c stm32l1xx_dma.c stm32l1xx_exti.c stm32l1xx_flash.c stm32l1xx_gpio.c stm32l1xx_i2c.c stm32l1xx_iwdg.c stm32l1xx_pwr.c stm32l1xx_rcc.c stm32l1xx_rtc.c stm32l1xx_spi.c stm32l1xx_syscfg.c stm32l1xx_tim.c stm32l1xx_usart.c stm32l1xx_wwdg.c
  group boards/port
    ../boards/stm32/port/: board.c cli_board.c sx1276_board.c serial_board.c
  group mac
    ../mac/: LoRaMac.c LoRaMacCrypto.c
  group radio
    ../radio/sx1276/: sx1276.c
  group system
    ../system/: debug.c delay.c fifo.c timer.c utilities.c
  group system/crypto
    ../system/crypto/: aes.c cmac.c
  group pro
    ../apps/protocol/: six_box_pto.c crc.c byte_handle.c
